# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c getKeyNum.c getKeyNum.h LCD.c LCD.h MatrixKeyboard.c MatrixKeyboard.h Menu.c Menu.h GlobalVariable.c GlobalVariable.h PageTurn.c PageTurn.h Time.c Time.h SetUp.c SetUp.h AlarmClock.c AlarmClock.h Delay.h Delay.c Delay500us.c Delay500us.h README.txt
